# Keil uVision project Project.uvprojx, settings and files
target izmelchitel (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: izmelchitel +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F0XX, USE_DEFAULT_TIMEOUT_CALLBACK,HSE_VALUE = 12000000
  c include: ..\stm32f0_lib\STM32F0xx_StdPeriphLib\Libraries\CMSIS\Device\ST\STM32F0xx\Include;..\stm32f0_lib\STM32F0xx_StdPeriphLib\Libraries\STM32F0xx_CPAL_Driver\inc;..\stm32f0_lib\STM32F0xx_StdPeriphLib\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\code;..\primak_lib\portable;..\stm32f0_lib\lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ./code/: main.cpp initialization.cpp interrupts.cpp current_measure.cpp status_led.cpp mini_modbus_tables.cpp
  group StdPeriph_Driver
    ../stm32f0_lib/STM32F0xx_StdPeriphLib/Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_dbgmcu.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
  group CMSIS
    ./code/: stm32f0xx_it.c startup_stm32f0xx.s
    ../stm32f0_lib/STM32F0xx_StdPeriphLib/Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: system_stm32f0xx.c
  group lib
    ../stm32f0_lib/lib/: delay.cpp filters.cpp GPIO.cpp mini_modbus.cpp packet_handler.cpp System.cpp UART_driver.cpp
    ../primak_lib/portable/: CRC.cpp
software components: CMSIS:CORE 4.3.0
